SRCREV = "2742e959347ae2fac58acd0d022c92a0ff1f24bf"
SRC_URI = "git://github.com/KhronosGroup/glslang.git;protocol=https;branch=main \
           file://0001-generate-glslang-pkg-config.patch"
