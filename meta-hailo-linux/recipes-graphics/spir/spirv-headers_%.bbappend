SRCREV = "b42ba6d92faf6b4938e6f22ddd186dbdacc98d78"
SRC_URI = "git://github.com/KhronosGroup/SPIRV-Headers;protocol=https;branch=main"
