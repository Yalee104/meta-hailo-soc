require recipes-core/images/core-image-minimal.bb
require include/core-image-append-dev.inc
