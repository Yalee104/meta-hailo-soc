require recipes-core/images/core-image-minimal.bb
require include/core-image-append.inc
IMAGE_OVERHEAD_FACTOR = "1.1"