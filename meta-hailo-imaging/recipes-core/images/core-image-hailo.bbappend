IMAGE_INSTALL += " packagegroup-hailo-imaging"