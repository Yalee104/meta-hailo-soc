IMAGE_INSTALL += " packagegroup-hailo-imaging-dev-pkg"
