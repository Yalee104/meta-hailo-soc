SUMMARY = "Verisilicon vivante SW package user space code build with basic components installed"

require imaging-sub-system.inc
inherit imaging-sub-system-base

LIBS_FILES_TO_COPY = ".so*"
