require files/core-image-append.inc