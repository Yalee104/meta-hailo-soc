IMAGE_INSTALL = "\
    base-files \
    base-passwd \
    busybox \
    mtd-utils \
    mtd-utils-ubifs \
    libgcc \
    libconfig \
    swupdate \
    util-linux-sfdisk \
    e2fsprogs-resize2fs \
    init-ifupdown \
    virtual/initscripts-hailo-swupdate \
    run-swupdate-script \
"
IMAGE_FSTYPES = "ext4.gz"