IMAGE_INSTALL:append = " packagegroup-hailo-media-library-dev-pkg"