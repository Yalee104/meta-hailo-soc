SRCREV="f7f5e5c2466ae649d29bcb42d5f3f1d8f115ab31"
SRC_URI="git://github.com/Yalee104/hailo-u-boot.git;protocol=https;branch=1.5.1"

